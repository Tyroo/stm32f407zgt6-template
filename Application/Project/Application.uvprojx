# Keil uVision project Application.uvprojx, settings and files
target Application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Application +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\System;..\System\Library\slib\inc;..\System\Library\elib\inc;..\Users\Main\inc;..\Users\TFTLCD\inc;..\Users\CanFestival\inc;..\Users\CanFestival\drive;..\Users\CanFestival\stm32;..\Users\FATFS\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MAIN
    ../Users/Main/src/: main.c delay.c led.c spi.c key.c i2c.c sys.c fsmc.c uart.c nvic.c can.c malloc.c
    ../Users/Main/inc/: delay.h led.h spi.h key.h fsmc.h can.h malloc.h
  group SLIB
    ../System/Library/slib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_it.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ELIB
    ../System/Library/elib/src/: ILI9341.c rgb.c
    ../System/Library/elib/inc/: ILI9341.h rgb.h
  group CORE
    ../System/Core/: startup_stm32f40_41xxx.s
    ../System/: system_stm32f4xx.c
  group TFTLCD
    ../Users/TFTLCD/src/: tftlcd.c tftlcd_element.c tftlcd_picture.c tftlcd_shape.c tftlcd_word.c tftlcd_conf.c tftlcd_event.c
    ../Users/TFTLCD/inc/: tftlcd_conf.h tftlcd_event.h
  group CANOPEN
    ../Users/CanFestival/drive/: TestMaster.c TestSlave.c
    ../Users/CanFestival/src/: canfestival.c dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
software components: CMSIS:CORE 5.5.0
